options:
  parameters:
    generate_options: qt_gui
    id: lab_analyseur_de_spectre
    output_language: python
    title: analyseur_de_spectre
  states: {}

blocks:
- name: f0
  id: variable
  parameters:
    value: 800e6
  states: {}
- name: fs
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: fs
    fc: f0
    fftsize: '2048'
    type: complex
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: fs
    center_freq0: f0
    gain0: '0.3'
    gain_type0: normalized
    samp_rate: fs
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
