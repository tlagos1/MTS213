options:
  parameters:
    generate_options: qt_gui
    id: lab_005
    output_language: python
    title: Transmission QPSK  - USRP HW in the Loop
  states: {}

blocks:
- name: Ar
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: RX Gain (lin.)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.82'
  states: {}
- name: As
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: TX Gain (lin.)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.6'
  states: {}
- name: f0
  id: variable
  parameters:
    value: 800e6
  states: {}
- name: fs
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: label_f0
  id: variable_qtgui_label
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Carrier Freq. (f0) [Hz]
    type: real
    value: f0
  states: {}
- name: label_fs
  id: variable_qtgui_label
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Sample Freq. (fs) [Hz]
    type: real
    value: fs
  states: {}
- name: sample_num
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tlagos/Documents/2 - FIP/MTS213/TP Rennes/dat/TPL1/rx_qpsk_rc_09.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tlagos/Documents/2 - FIP/MTS213/TP Rennes/dat/TPL1/qpsk_rc_09.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: fs
    color1: '"red"'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,5,2,2
    legend: 'False'
    name: TX - IQ Baseband Signal to USRP
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: fs
    color1: '"red"'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,5,2,2
    legend: 'False'
    name: RX - IQ Baseband Signal from USRP
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 4,1
    label0: RF Options
    num_tabs: '1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1,2,2
    label1: Re
    label2: Im
    name: TX IQ Baseband Signal to USRP
    size: sample_num
    srate: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,2,2
    label1: Re
    label2: Im
    name: RX IQ Baseband Signal  from USRP
    size: sample_num
    srate: fs
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: f0
    clock_rate: '0.0'
    dev_args: '""'
    gain0: As
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: fs
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: f0
    clock_rate: '0.0'
    dev_args: '""'
    gain0: Ar
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: fs
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
